Commit message: clean up .pyc file

File: edufill_sw/edufill_simulation/edufill_gazebo_world/common/worlds/edufill_maze.urdf (robot description, URDF)
Before this commit: robot maze, 1 links, 0 joints
Links:
- link maze: mass 10.0 -> 100.0
