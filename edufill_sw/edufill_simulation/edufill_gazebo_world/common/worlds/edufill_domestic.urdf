Commit message: change domestic map and gripper

File: edufill_sw/edufill_simulation/edufill_gazebo_world/common/worlds/edufill_domestic.urdf (robot description, URDF)
Before this commit: robot room, 1 links, 0 joints
Links:
- link room: mass 10.0 -> 100.0
